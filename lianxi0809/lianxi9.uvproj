# Keil uVision project lianxi9.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: lianxi9 +hex
  c flags: Optimize=8 SizeSpeed=1
  group lianxi9
    ./: STARTUP.A51 lianxi9.c
